IMAGE_INSTALL_append = " peekpoke"
IMAGE_INSTALL_append = " gpio-demo"
IMAGE_INSTALL_append = " test-gpio"
IMAGE_INSTALL_append = " test-app-1"
